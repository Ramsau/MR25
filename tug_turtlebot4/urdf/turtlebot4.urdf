Commit message: Added exercise 4

File: tug_turtlebot4/urdf/turtlebot4.urdf (robot description, URDF)
Before this commit: robot tug_turtlebot4, 39 links, 38 joints
Links:
- link right_wheel: geometry collision cylinder length=0.015 radius=0.03575; visual cylinder length=0.015 radius=0.03575
